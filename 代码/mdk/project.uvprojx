# Keil uVision project project.uvprojx, settings and files
target project (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project +hex
  AfterMake: fromelf.exe --bin -o "%L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\app\inc;..\fireware\cmsis\core;..\fireware\cmsis\device;..\fireware\driver\inc;..\driver\dht11;..\driver\esp8266;..\driver\led;..\driver\onenet;..\driver\oled;..\driver\timer;..\third_lib\emwin\config;..\third_lib\emwin\inc;..\third_lib\freertos\include;..\third_lib\freertos\portable\RVDS\ARM_CM3;..\driver\debug;..\driver\delay
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group app
    ../app/: main.c task_dht11.c task_ui.c task_wifi.c task_led.c
    ../: ReadMe.txt
    ../app/inc/: FreeRTOSConfig.h
  group driver
    ../driver/oled/: oled.c
    ../driver/led/: led.c
    ../driver/debug/: debug.c
    ../driver/delay/: delay.c
    ../driver/dht11/: dht11.c
    ../driver/esp8266/: esp8266.c
    ../driver/onenet/: onenet.c
  group fireware
    ../fireware/cmsis/core/: core_cm3.c
    ../fireware/cmsis/device/: stm32f10x_it.c system_stm32f10x.c startup_stm32f10x_hd.s
    ../fireware/driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_crc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group third_lib/freertos
    ../third_lib/freertos/portable/MemMang/: heap_4.c
    ../third_lib/freertos/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../third_lib/freertos/portable/RVDS/ARM_CM3/: port.c portmacro.h
  group third_lib/emwin
    ../third_lib/emwin/config/: GUIConf.c GUIDRV_Template.c LCDConf_FlexColor_Template.c
    ../third_lib/emwin/lib/: STemWin522_CM3_OS_Keil.lib
    ../third_lib/emwin/os/: GUI_X_FreeRTOS.c
